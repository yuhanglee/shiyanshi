# Keil uVision project OTG.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: OTG +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source;..\Source\driver;..\Source\system;..\Source\WCOS\App;..\Source\WCOS\Kernel;..\Source\WCOS\Platform
  group SysDri
    ./: STARTUP.A51
    ../Source/system/: uart.c timer.c iic.c delay.c
    ../Source/driver/: led.c
  group PerDri
    ../Source/driver/: max485.c key.c 24c02.c gt20.c oled.c
  group App
    ../Source/: main.c botp.c crc.c
